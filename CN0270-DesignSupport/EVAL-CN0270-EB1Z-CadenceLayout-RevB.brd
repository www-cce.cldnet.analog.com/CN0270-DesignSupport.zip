# Allegro board EVAL-CN0270-EB1Z-CadenceLayout-RevB.brd (continued)
## Text on the board (continued)
User.9: 08-      -02 | LAYER2 SECONDARY SIDE
User.11: 08-      -07 | LAYER2_AGND
User.12: 08-      -08 | LAYER3_DGND
User.14: SECONDARY SIDE PASTEMASK | 08-      -12
User.17: 08-      -07 | L2 GND
User.18: 08-      -08 | L3 PWR
User.33: FIGURE | SIZE | 12.0 | 40.0 | 45.0 | 50.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | PLATED | QTY | 177 | 14 | 39 | 4
